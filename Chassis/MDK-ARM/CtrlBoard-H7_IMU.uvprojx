# Keil uVision project CtrlBoard-H7_IMU.uvprojx, settings and files
target CtrlBoard-H7_IMU (6120000::V6.12::.\ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CtrlBoard-H7_IMU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,USE_PWR_LDO_SUPPLY
  c misc: -Wno-ignored-attributes
  c include: ../Core/Inc;../../Shared/Drivers/STM32H7xx_HAL_Driver/Inc;../../Shared/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../../Shared/Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../Shared/Drivers/CMSIS/Include;../../Shared/Drivers/CMSIS/DSP/Include;../../Shared/ThirdParty/FreeRTOS/ARM_CM4F_AC6;../../Shared/Algorithm/mahony;../User/APP;../User/Bsp;../../Shared/Devices/BMI088;../../Shared/Algorithm/PID;../../Shared/Devices/Remote_Control;../../Shared/Devices/DJI_Motor;../../Shared/Algorithm/CRC;../USB_DEVICE/App;../USB_DEVICE/Target;../../Shared/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../Shared/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../Shared/Devices/PC_Comm;../../Shared/Devices/QD4310_Motor;../../Shared/Protocol/VOFA;../../Shared/Middlewares/Third_Party/FreeRTOS/Source/include;../../Shared/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../Shared/Drivers/CMSIS/RTOS2/Include;../../Shared/Protocol/BoardLink;../../Shared/Bsp
  asm include: ../../Shared/Drivers/CMSIS/Include;../../Shared/Bsp;../../Shared/Protocol/BoardLink
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Shared/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Device
    ../../Shared/Devices/BMI088/: BMI088driver.c BMI088Middleware.c
    ../../Shared/Devices/DJI_Motor/: DJI_Motor.c
    ../../Shared/Devices/PC_Comm/: PC_Comm.c
    ../../Shared/Devices/QD4310_Motor/: QD4310_Motor.c
  group Algorithm
    ../../Shared/Algorithm/mahony/: mahony_filter.c
    ../../Shared/Algorithm/PID/: pid.c
    ../../Shared/Algorithm/CRC/: CRC.c
  group DSP
    ../../Shared/Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group Middlewares/FreeRTOS
    ../../Shared/ThirdParty/FreeRTOS/ARM_CM4F_AC6/: port.c
    ../../Shared/Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../../Shared/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Shared/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../Shared/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group APP
    ../User/APP/: ins_task.c chassis_task.c input_task.c service_task.c led_system.c vofa_system.c board_link.c
  group Protocol
    ../../Shared/Protocol/VOFA/: vofa.c
    ../../Shared/Protocol/BoardLink/: board_link_protocol.c board_link_payload.c
  group bsp
    ../../Shared/Bsp/: bsp_dwt.c
    ../User/Bsp/: bsp_uart.c bsp_can.c bsp_usb.c bsp_ws2812.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../../Shared/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Shared/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
