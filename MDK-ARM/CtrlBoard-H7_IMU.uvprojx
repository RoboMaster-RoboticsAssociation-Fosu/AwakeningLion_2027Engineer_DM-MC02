# Keil uVision project CtrlBoard-H7_IMU.uvprojx, settings and files
target CtrlBoard-H7_IMU (6120000::V6.12::.\ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CtrlBoard-H7_IMU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,USE_PWR_LDO_SUPPLY
  c misc: -Wno-ignored-attributes
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../User/ThirdParty/FreeRTOS/ARM_CM4F_AC6;../User/Algorithm/EKF;../User/Algorithm/kalman;../User/Algorithm/mahony;../User/APP;../User/Bsp;../User/Devices/BMI088;../User/Devices/DM_Motor;../User/Algorithm/VMC;../User/Controller;../User/Lib;../User/Algorithm/PID;../User/Algorithm/filter;../User/Devices/Remote_Control;../User/Devices/Button;../User/Devices/DJI_Motor;../User/Config;../User/Devices/Unitree_Motor;../User/Algorithm/FIFO;../User/Algorithm/CRC;../User/Algorithm/Arm;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../User/Devices/PC_Comm;../User/Devices/PS2_Device;../User/Devices/HWT6033;../User/Protocol/DbgDisp;../User/Protocol/VOFA;../User/Protocol/CustomController;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Drivers/CMSIS/RTOS2/Include;../User/Devices/RS05_Motor;../User/Protocol/BoardLink
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Device
    ../User/Devices/BMI088/: BMI088driver.c BMI088Middleware.c
    ../User/Devices/Remote_Control/: Remote_Control.c
    ../User/Devices/Button/: Button.c
    ../User/Devices/DJI_Motor/: DJI_Motor.c
    ../User/Devices/Unitree_Motor/: Unitree_Motor.c
    ../User/Devices/DM_Motor/: DM_Motor.c
    ../User/Devices/PC_Comm/: PC_Comm.c
    ../User/Devices/PS2_Device/: PS2_Device.c
    ../User/Devices/HWT6033/: wit_c_sdk.c HWT6033.c
    ../User/Devices/RS05_Motor/: RS05_Motor.c
  group Algorithm
    ../User/Algorithm/mahony/: mahony_filter.c
    ../User/Algorithm/EKF/: QuaternionEKF.c
    ../User/Algorithm/VMC/: VMC_calc.c
    ../User/Algorithm/kalman/: kalman_filter.c
    ../User/Lib/: user_lib.c
    ../User/Algorithm/PID/: pid.c
    ../User/Algorithm/FIFO/: FIFO.c
    ../User/Algorithm/CRC/: CRC.c
    ../User/Algorithm/Arm/: arm_gravity_compensation.c arm_control_filter.c arm_custom_grip.c
  group DSP
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group Middlewares/FreeRTOS
    ../User/ThirdParty/FreeRTOS/ARM_CM4F_AC6/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group APP
    ../User/APP/: ins_task.c chassis_task.c arm_task.c input_task.c rc_system.c custom_controller_system.c service_task.c led_system.c vofa_system.c board_link.c
  group Protocol
    ../User/Protocol/DbgDisp/: DbgDisp.c
    ../User/Protocol/VOFA/: vofa.c
    ../User/Protocol/CustomController/: custom_controller_protocol.c
    ../User/Protocol/BoardLink/: board_link_protocol.c board_link_payload.c
  group bsp
    ../User/bsp/: bsp_dwt.c
    ../User/Bsp/: bsp_PWM.c bsp_uart.c bsp_can.c bsp_usb.c bsp_ws2812.c
  group Controller
    ../User/Controller/: controller.c
  group Config
    ../User/Config/: user_sys_config.h
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
